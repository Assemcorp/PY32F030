# IAR project Project.ewp, settings and files
configuration PY32F031x8_Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32F031x8 Puya PY32F031x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F031x8
  ICCARM.CCIncludePath2: ..\..\..\Drivers\CMSIS\Device\PY32F031\Include; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\PY32F031_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f031x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration PY32F031x7_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F031x7 Puya PY32F031x7
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F031x7
  ILINK.IlinkIcfFile: py32f031x7_flash.icf
configuration PY32F031x6_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F031x6 Puya PY32F031x6
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F031x6
  ILINK.IlinkIcfFile: py32f031x6_flash.icf
configuration PY32F031x4_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F031x4 Puya PY32F031x4
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F031x4
  ILINK.IlinkIcfFile: py32f031x4_flash.icf
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_py32f031.c
  group Drivers/PY32F031_HAL_Driver
    ../../../Drivers/PY32F031_HAL_Driver/Src/: py32f031_hal.c py32f031_hal_cortex.c py32f031_hal_dma.c py32f031_hal_gpio.c py32f031_hal_pwr.c py32f031_hal_rcc.c py32f031_hal_rcc_ex.c
  group Example/EWARM
    ./: startup_py32f031xx.s
  group Example/User
    ../Src/: main.c py32f031_hal_msp.c py32f031_it.c
