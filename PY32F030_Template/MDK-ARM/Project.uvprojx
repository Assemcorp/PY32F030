# Keil uVision project Project.uvprojx, settings and files
target PY32F031x8_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F031x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F031x8
  c include: ..\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F031\Include;..\Drivers\PY32F031_HAL_Driver\Src;..\Drivers\PY32F031_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ./: startup_py32f031xx.s
    ../Src/: system_py32f031.c
  group Application/User
    ../Src/: main.c py32f031_hal_msp.c py32f031_it.c init.c
  group Drivers/PY32F031_HAL_Driver
    ../Drivers/PY32F031_HAL_Driver/Src/: py32f031_hal.c py32f031_hal_adc.c py32f031_hal_comp.c py32f031_hal_cordic.c py32f031_hal_cortex.c py32f031_hal_crc.c py32f031_hal_dma.c py32f031_hal_exti.c py32f031_hal_flash.c py32f031_hal_gpio.c py32f031_hal_hdiv.c py32f031_hal_i2c.c py32f031_hal_i2s.c py32f031_hal_iwdg.c py32f031_hal_lcd.c py32f031_hal_lptim.c py32f031_hal_opa.c py32f031_hal_opa_ex.c py32f031_hal_pwr.c py32f031_hal_rcc.c py32f031_hal_rcc_ex.c py32f031_hal_rtc.c py32f031_hal_rtc_ex.c py32f031_hal_spi.c py32f031_hal_tim.c py32f031_hal_tim_ex.c py32f031_hal_uart.c py32f031_hal_usart.c py32f031_hal_wwdg.c py32f031_ll_adc.c py32f031_ll_comp.c py32f031_ll_cordic.c py32f031_ll_crc.c py32f031_ll_dma.c py32f031_ll_exti.c py32f031_ll_gpio.c py32f031_ll_i2c.c py32f031_ll_lcd.c py32f031_ll_lptim.c py32f031_ll_pwr.c py32f031_ll_rcc.c py32f031_ll_rtc.c py32f031_ll_spi.c py32f031_ll_tim.c py32f031_ll_usart.c py32f031_ll_utils.c
  group Doc
    ../: readme.txt
target PY32F031x7_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F031x7 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x0000C000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F031x7
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\PY32F031\Include;..\..\..\Drivers\PY32F031_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x1800
target PY32F031x6_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F031x6 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F031x6
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
target PY32F031x4_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F031x4 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F031x4
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
software components: CMSIS:CORE 5.2.0
